# Keil uVision project proximity_sensor.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: proximity_sensor
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../shared_libs
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c
    ../shared_libs/: gpio_lib.c gpio_lib.h sens_brd.h
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.2, nRF_Drivers:nrf_delay 4.0.0-2.alpha
