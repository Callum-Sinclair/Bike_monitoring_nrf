# Keil uVision project ble_app_hrs_rscs_relay_pca10036.uvprojx, settings and files
target nrf52832_xxaa_s132 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S132 NRF52_PAN_8 NRF52_PAN_9 NRF52_PAN_10 NRF52_PAN_11 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_16 NRF52_PAN_17 NRF52_PAN_20 NRF52_PAN_23 NRF52_PAN_24 NRF52_PAN_25 NRF52_PAN_26 NRF52_PAN_27 NRF52_PAN_28 NRF52_PAN_29 NRF52_PAN_30 NRF52_PAN_32 NRF52_PAN_33 NRF52_PAN_34 NRF52_PAN_35 NRF52_PAN_36 NRF52_PAN_37 NRF52_PAN_38 NRF52_PAN_39 NRF52_PAN_40 NRF52_PAN_41 NRF52_PAN_42 NRF52_PAN_43 NRF52_PAN_44 NRF52_PAN_46 NRF52_PAN_47 NRF52_PAN_48 NRF52_PAN_49 NRF52_PAN_58 NRF52_PAN_63 NRF52_PAN_64 NRF52_PAN_65 CONFIG_GPIO_AS_PINRESET BOARD_PCA10036 NRF52_PAN_1 NRF52_PAN_2 NRF52_PAN_3 NRF52_PAN_4 NRF52_PAN_7 NRF_LOG_USES_UART=1 SOFTDEVICE_PRESENT NRF52 SWI_DISABLE0
  c misc: --c99
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1b000 size 0x65000
  memory RVCT9: RAM 0x20002f80 size 0x5080
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
target flash_s132_nrf52_2.0.0-7.alpha_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s132_nrf52_2.0.0-7.alpha_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF52
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.1, nRF_Libraries:app_button 4.0.0-2.alpha, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_hrs 4.0.0-2.alpha, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_db_discovery 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_data_storage 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_SoftDevice:s132 2.0.0-7.alpha, nRF_BLE:BLE_Modules:gatt_cache_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:id_manager 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_BLE:BLE_Modules:pm_mutex 4.0.0-2.alpha, nRF_BLE:BLE_Modules:gattc_cache_manager 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_manager 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_rscs 4.0.0-2.alpha, nRF_SoftDevice:s132_hex 2.0.0-7.alpha, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, Board Support:bsp_btn_ble 11.0.0-2.alpha, nRF_BLE:BLE_Services:ble_rscs_c 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_id 4.0.0-2.alpha, nRF_Libraries:fstorage 4.0.0-2.alpha, nRF_Libraries:nrf_log 4.0.0-2.alpha, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Libraries:retarget 4.0.0-2.alpha, Board Support:bsp 11.0.0-2.alpha, nRF_Libraries:experimental_section_vars 4.0.0-2.alpha, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_data 4.0.0-2.alpha, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:sdk_mapped_flags 4.0.0-2.alpha, nRF_BLE:BLE_Modules:peer_database 4.0.0-2.alpha, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_BLE:BLE_Modules:pm_buffer 4.0.0-2.alpha, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_BLE:BLE_Modules:gatts_cache_manager 4.0.0-2.alpha, nRF_Libraries:app_trace 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_state 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advertising 4.0.0-2.alpha, nRF_BLE:BLE_Modules:security_dispatcher 4.0.0-2.alpha, nRF_Drivers:nrf_drv_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Libraries:fds 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:security_manager 4.0.0-2.alpha, nRF_Libraries:segger_rtt 1.2.1-2.alpha, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_hrs_c 4.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha
