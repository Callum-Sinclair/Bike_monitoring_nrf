# Keil uVision project hub.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hub
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../shared_libs
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../shared_libs/: gpio_lib.c gpio_lib.h hub_brd.h
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, Device:Startup 8.3.2, nRF_Drivers:nrf_delay 4.0.0-2.alpha
