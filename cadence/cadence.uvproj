# Keil uVision project cadence.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(64000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: cadence
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: arm_startup_nrf52.s
